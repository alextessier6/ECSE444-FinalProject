# Keil uVision project G00Lab1.uvprojx, settings and files
target G00Lab1 (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: G00Lab1
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ./inc; ./RTE
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./src/: main.c
  group inc
    ./inc/: asm_max.h
  group asm
    ./asm/: asm_max.s asm_dp.s
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, Device:Startup 1.0.1, Compiler:I/O:STDOUT 1.4.0
